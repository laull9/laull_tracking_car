# Keil uVision project test_1.uvprojx, settings and files
target test_1 (ARM-ADS)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: test_1
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=6 wLevel=3
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: Drivers;Drivers\CMSIS\Device\ST\STM32F1xx\Include;Drivers\STM32F1xx_HAL_Driver\Inc;Drivers\CMSIS\Include;User;Middlewares;Middlewares\USB\STM32_USB_Device_Library\Core\Inc;Middlewares\USB\STM32_USB_Device_Library\Class\MSC\Inc;Middlewares\USB\USB_APP;Drivers\BSP;Middlewares\FATFS\source;Middlewares\FATFS\exfuns;.cmsis\include;RTE\_elite_test;Middlewares\USMART;Drivers\BSP\ATK_MO1053;Drivers\BSP\VS10XX
  asm define: USE_HAL_DRIVER,STM32F103xE
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Middlewares/USMART
    Middlewares/USMART/: usmart.c usmart_config.c usmart_port.c usmart_str.c
  group Middlewares/PICTURE
    Middlewares/PICTURE/: bmp.c gif.c piclib.c tjpgd.c
  group Middlewares/FATFS
    Middlewares/FATFS/exfuns/: exfuns.c fattester.c myffunicode.c
    Middlewares/FATFS/source/: diskio.c ff.c ffsystem.c
  group Middlewares/TEXT
    Middlewares/TEXT/: fonts.c text.c
  group Middlewares/USB_APP
    Middlewares/USB/USB_APP/: usbd_conf.c usbd_desc.c usbd_storage.c
  group Middlewares/USB_CLASS
    Middlewares/USB/STM32_USB_Device_Library/Class/MSC/Src/: usbd_msc.c usbd_msc_bot.c usbd_msc_data.c usbd_msc_scsi.c
  group Middlewares/USB_CORE
    Middlewares/USB/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
  group Middlewares/MALLOC
    Middlewares/MALLOC/: malloc.c
  group Drivers/STM32F1xx_HAL_Driver
    Drivers/STM32F1xx_HAL_Driver/Src/Legacy/: stm32f1xx_hal_can.c
    Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_cec.c stm32f1xx_hal_cortex.c stm32f1xx_hal_crc.c stm32f1xx_hal_dac.c stm32f1xx_hal_dac_ex.c stm32f1xx_hal_dma.c stm32f1xx_hal_eth.c stm32f1xx_hal_exti.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_hcd.c stm32f1xx_hal_i2c.c stm32f1xx_hal_i2s.c stm32f1xx_hal_irda.c stm32f1xx_hal_iwdg.c stm32f1xx_hal_mmc.c stm32f1xx_hal_msp_template.c stm32f1xx_hal_nand.c stm32f1xx_hal_nor.c stm32f1xx_hal_pccard.c stm32f1xx_hal_pcd.c stm32f1xx_hal_pcd_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_rtc.c stm32f1xx_hal_rtc_ex.c stm32f1xx_hal_sd.c stm32f1xx_hal_smartcard.c stm32f1xx_hal_spi.c stm32f1xx_hal_sram.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_timebase_rtc_alarm_template.c stm32f1xx_hal_uart.c stm32f1xx_hal_usart.c stm32f1xx_hal_wwdg.c stm32f1xx_ll_adc.c stm32f1xx_ll_crc.c stm32f1xx_ll_dac.c stm32f1xx_ll_dma.c stm32f1xx_ll_exti.c stm32f1xx_ll_fsmc.c stm32f1xx_ll_gpio.c stm32f1xx_ll_i2c.c stm32f1xx_ll_pwr.c stm32f1xx_ll_rcc.c stm32f1xx_ll_rtc.c stm32f1xx_ll_sdmmc.c stm32f1xx_ll_spi.c stm32f1xx_ll_tim.c stm32f1xx_ll_usart.c stm32f1xx_ll_usb.c stm32f1xx_ll_utils.c
  group Drivers/BSP
    Drivers/BSP/LED/: led.c
    Drivers/BSP/LCD/: lcd.c
    Drivers/BSP/KEY/: key.c
    Drivers/BSP/SDIO/: sdio_sdcard.c
    Drivers/BSP/SPI/: spi.c
    Drivers/BSP/NORFLASH/: norflash.c
    Drivers/BSP/BEEP/: beep.c
    Drivers/BSP/ADC/: adc.c adc3.c
    Drivers/BSP/REMOTE/: remote.c
    Drivers/BSP/LSENS/: lsens.c
    Drivers/BSP/IIC/: myiic.c
    Drivers/BSP/24CXX/: 24cxx.c
    Drivers/BSP/TIMER/: gtim.c
    Drivers/BSP/OLED/: oled.c
    Drivers/BSP/TOUCH/: ctiic.c ft5206.c gt9xxx.c touch.c
    Drivers/BSP/ATK_MO1053/: atk_mo1053.c
  group Drivers/SYSTEM
    Drivers/SYSTEM/delay/: delay.c
    Drivers/SYSTEM/sys/: sys.c
    Drivers/SYSTEM/usart/: usart.c
  group User
    Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
    User/: stm32f1xx_it.c laullstm32.h laullstm32ui.h laullstm32.c main.c
    Middlewares/TEST/: test.c
  group startup
    Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/arm/: startup_stm32f103xe.s
